Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-10-11T16:18:21
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Basic Wall:NBS_DeltaMembraneSystemsLtd_ButylRubberAdhesiveTapes_KosterJointTape20, Basic Wall:NBS_DeltaMembraneSystemsLtd_ButylRubberAdhesiveTapes_KosterJointTape20:222031
In: Level 0
Type - Material: NBS_DeltaMembraneSystemsLtd_ButylRubberAdhesiveTapes_KosterJointTape20 0.8 mm
Type - IFC - IfcExportAs: IfcCoveringType
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_35_90_87_07:Butyl rubber adhesive tapes; Color: n/a; Finish: n/a; Material: n/a; Shape: n/a; Size: n/a; WarrantyDescription: Ten year; CodePerformance: n/a; Constituents: n/a; Description: Elastic sealing tape for waterproofing joints and irregular cracks.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Koster Joint Tape 20; Name: ButylRubberAdhesiveTapes_KosterJointTape20_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_ButylRubberAdhesiveTapes_KosterJointTape20; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/8ce894d6-1964-db70-87fc-0f0e3a176eff/6fcb69f5-0f99-4443-a6fd-f8bb135298d8; Uniclass2015Code: Pr_35_90_87_07; Uniclass2015Title: Butyl rubber adhesive tapes; Uniclass2015Version: Products v1.35; Version: 5
Type - NBS_Data - Colour: Grey; ContainsRedListMaterials: No; Recyclability: No; RecycledContent: 0; ElongationAtBreak: >400%; ShoreAHardness: 80; Strength: >20 N/10 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:NBS_DeltaMembraneSystemsLtd_ButylRubberAdhesiveTapes_KosterJointTape20, Floor:NBS_DeltaMembraneSystemsLtd_ButylRubberAdhesiveTapes_KosterJointTape20:221887
In: Level 0
Type - Material: NBS_DeltaMembraneSystemsLtd_ButylRubberAdhesiveTapes_KosterJointTape20 0.8 mm
Type - IFC - IfcExportAs: IfcCoveringType
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_35_90_87_07:Butyl rubber adhesive tapes; Color: n/a; Finish: n/a; Material: n/a; Shape: n/a; Size: n/a; WarrantyDescription: Ten year; CodePerformance: n/a; Constituents: n/a; Description: Elastic sealing tape for waterproofing joints and irregular cracks.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Koster Joint Tape 20; Name: ButylRubberAdhesiveTapes_KosterJointTape20_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_ButylRubberAdhesiveTapes_KosterJointTape20; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/8ce894d6-1964-db70-87fc-0f0e3a176eff/57c56671-b557-4427-9cd6-a78afee23d93; Uniclass2015Code: Pr_35_90_87_07; Uniclass2015Title: Butyl rubber adhesive tapes; Uniclass2015Version: Products v1.35; Version: 4
Type - NBS_Data - Colour: Grey; ContainsRedListMaterials: No; Recyclability: No; RecycledContent: 0; ElongationAtBreak: >400%; ShoreAHardness: 80; Strength: >20 N/10 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
